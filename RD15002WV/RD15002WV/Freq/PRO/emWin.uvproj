# Keil uVision project emWin.uvproj, settings and files
target Freq (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: emWin +hex
  c flags: Optim=3
  c define: USE_STDPERIPH_DRIVER,STM32F4XX
  c include: ..\App;..\App\BSP;..\LIB\INC;..\LIB\SRC;..\emWin\Config;..\emWin\inc;..\emWin\Lib;..\uCOSIII\uC-CPU;..\uCOSIII\uC-LIB;..\uCOSIII\uC-Serial\Driver;..\uCOSIII\uC-Serial\Line;..\uCOSIII\uC-Serial\Source;..\uCOSIII\uC-Serial\OS;..\uCOSIII\uCOS-III\Ports;..\uCOSIII\uCOS-III\Source;..\emWin\Demo;..\App\APP;..\Protocol\drv\inc;..\Protocol\drv\src;..\Protocol\Protocol;..\Protocol\sys
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ../App/: bsp.c main.c os_app_hooks.c bsp.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.h os_cfg.h os_cfg_app.h
  group APP
    ../App/APP/: app.c FreqMeasurement.c app.h Tools.c
  group BSP
    ../App/BSP/: bsp_init.c bsp_usart.c bsp_ltc2402.c bsp_sst25vf064.c bsp_rtc.c bsp_io_control.c stm32f4xx_it.c stm32f4xx.h stm32f4xx_conf.h bsp_adc.c
  group Protocol
    ../Protocol/Protocol/: AppMain.c
  group drv
    ../Protocol/drv/src/: Protocol.c usart_serial.c
  group sys
    ../Protocol/sys/: kernel.c
  group CMSIS
    ../App/BSP/: system_stm32f4xx.c
    ../LIB/: startup_stm32f40_41xxx.s
  group STLib
    ../LIB/SRC/: misc.c stm32f4xx_crc.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_spi.c stm32f4xx_rtc.c stm32f4xx_pwr.c stm32f4xx_wwdg.c stm32f4xx_iwdg.c stm32f4xx_adc.c
  group uCOSIII/Cpu
    ../uCOSIII/uC-CPU/: cpu.h cpu_a.asm cpu_c.c cpu_core.c cpu_core.h cpu_def.h
  group uCOSIII/Ports
    ../uCOSIII/uCOS-III/Ports/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group uCOSIII/Src
    ../uCOSIII/uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
  group uCOSIII/Lib
    ../uCOSIII/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_mem_a.asm lib_str.c lib_str.h

# Keil uVision project project.uvproj, settings and files
target SCT (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: project
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F4XX
  c include: ..\code\app\inc;..\code\app\src;..\code\bsp\inc;..\code\bsp\src;..\code\drv\inc;..\code\drv\src;..\code\sys\Include;..\code\sys;..\code\test;..\code\user
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group app
    ../code/app/src/: AppMain.c FreqMeasurement.c Rain.c Temperature.c usart_serial.c
  group bsp
    ../code/bsp/src/: misc.c stm32f4xx_adc.c stm32f4xx_crc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group drv
    ../code/drv/src/: bsp_adc.c bsp_init.c bsp_io_control.c bsp_rtc.c bsp_sst25vf064.c bsp_usart.c bsp_flash.c stm32f4xx_it.c system_stm32f4xx.c
  group sys
    ../code/sys/: kernel.c malloc.c startup_stm32f40_41xxx.s Protocol.c
  group user
    ../code/user/: Tools.c main.c

# IAR project SCT_430.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430fn.h
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: ..\code\app\inc; ..\code\app\src; ..\code\bsp\inc; ..\code\bsp\src; ..\code\drv\inc; ..\code\drv\src; ..\code\sys\include; ..\code\sys; ..\code\test; ..\code\user
  ICC430.CCOptLevel: 0
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430f149.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group app
    ../code/app/src/: DTprotocol.c FirmwareUpdate.c freq.c LoopRamFunc.c RTCTime.c temperature.c Voltage.c Zigbee.c
  group bsp
    ../code/bsp/src/: msp430f149_adc.c msp430f149_flash.c msp430f149_gpio.c msp430f149_rtc.c msp430f149_spi.c msp430f149_timer.c msp430f149_uart.c msp430f149_wdt.c
  group drv
    ../code/drv/src/: Beep.c JN5139.c LTC2402.c Power.c Vibration.c
  group sys
    ../code/sys/: kernel.c
  group test
    ../code/test/: testadc.c testflash.c testfreq.c testramloop.c testspi.c testtimer.c testusart.c testzigbee.c
  group user
    ../code/user/: main.c

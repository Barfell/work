# IAR project SCT_430.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430fn.h
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: E:\PROJECT\SCT\SCT_430\code\app\inc; E:\PROJECT\SCT\SCT_430\code\app\src; E:\PROJECT\SCT\SCT_430\code\bsp\src; E:\PROJECT\SCT\SCT_430\code\bsp\inc; E:\PROJECT\SCT\SCT_430\code\drv; E:\PROJECT\SCT\SCT_430\code\sys; E:\PROJECT\SCT\SCT_430\code\sys\include; E:\PROJECT\SCT\SCT_430\code\test; E:\PROJECT\SCT\SCT_430\code\user; E:\PROJECT\SCT\SCT_430\code\drv\inc; E:\PROJECT\SCT\SCT_430\code\drv\src
  ICC430.CCOptLevel: 0
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430f149.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group app
    ../code/app/src/: DTprotocol.c LoopRamFunc.c Voltage.c Zigbee.c
  group bsp
    ../code/bsp/src/: msp430f149_adc.c msp430f149_flash.c msp430f149_gpio.c msp430f149_uart.c
  group drv
    ../code/drv/src/: Beep.c JN5139.c Power.c
  group sys
    ../code/sys/: kernel.c
  group test
    ../code/test/: testadc.c testflash.c testfreq.c testramloop.c testspi.c testtimer.c testusart.c testzigbee.c
  group user
    ../code/user/: main.c

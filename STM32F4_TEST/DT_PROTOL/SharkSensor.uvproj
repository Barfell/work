# Keil uVision project SharkSensor.uvproj, settings and files
target SharkSenor (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: SharkSensor
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F4XX
  c include: .\App;.\CMSIS;.\StartUp;.\STM32F4xx_StdPeriph_Driver\inc;.\STM32F4xx_StdPeriph_Driver\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group StartUp
    ./StartUp/: startup_stm32f40xx.s
  group CMSIS
    ./CMSIS/: system_stm32f4xx.c
  group STM32F4_STDLIB
    ./STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_dac.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_dma.c
  group App
    ./App/: main.c stm32f4xx_it.c PeriphInit.c stm32f4xx_conf.h DTprotocol.c

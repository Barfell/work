# Keil uVision project Pro.uvproj, settings and files
target L4 (ARM-ADS)
  device: STM32L471RETx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x00080000) IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Pro
  c flags: Optim=1 wLevel=2
  c define: USE_HAL_DRIVER
  c include: .\App;.\CMSIS;.\StartUp;.\STM32L4xx_HAL_Driver\Src;.\STM32L4xx_HAL_Driver\Inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group usr
    ./App/: main.c stm32l4xx_it.c system_stm32l4xx.c stm32l4xx_hal_conf.h stm32l4xx_it.h
  group lib
    ./STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_rcc.c stm32l4xx_hal_pwr_ex.c
    ./STM32L4xx_HAL_Driver/Inc/Legacy/: stm32_hal_legacy.h
  group startup
    ./StartUp/: startup_stm32l471xx.s

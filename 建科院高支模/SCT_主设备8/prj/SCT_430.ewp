# IAR project SCT_430.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xllfn.h
  General.OGChipSelectMenu: MSP430F47187 MSP430F47187
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: ..\code\app\inc; ..\code\app\src; ..\code\bsp\inc; ..\code\bsp\src; ..\code\drv\inc; ..\code\drv\src; ..\code\sys\include; ..\code\sys; ..\code\test; ..\code\user
  ICC430.CCOptLevel: 0
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430f47187.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group app
    ../code/app/src/: cmd.c dtprotocol.c ecc.c firmwareupdate.c freq.c level.c rain.c ramloop.c s485.c sensor.c voltage.c
  group bsp
    ../code/bsp/src/: clk.c flash.c gpio.c rtc.c sd.c spi.c timer.c uart.c wdt.c
  group drv
    ../code/drv/src/: beep.c dtu.c jn5139.c key.c ltc2402.c power.c rf.c sst25vf064c.c vibration.c
  group sys
    ../code/sys/: kernel.c
  group test
    ../code/test/: test.h test485.c testadc.c testdtu.c testecc.c testflash.c testfreq.c testrain.c testramloop.c testrf.c testrtc.c testspi.c testsst25vf064.c testtimer.c testusart.c testzigbee.c
  group user
    ../code/user/: cfg.h ch8_center.c includes.h log.txt main.c signel.c

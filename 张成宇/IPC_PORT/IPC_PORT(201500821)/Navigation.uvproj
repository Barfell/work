# Keil uVision project Navigation.uvproj, settings and files
target Navigation (ARM-ADS)
  device: STM32F101C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x200027FF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Navigation
  AfterMake: fromelf --bin  --output ./BIN/Navigation.bin ./Output/Navigation.axf
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\CMSIS\inc;.\StdPeriph_Driver_3.12\inc;.\User\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group CMSIS
    ./CMSIS/src/: core_cm3.c system_stm32f10x.c
  group RVMDK
    ./RVMDK/: startup_stm32f10x_hd.s
  group StdPeriph_Driver_3.12
    ./StdPeriph_Driver_3.12/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_exti.c stm32f10x_rtc.c stm32f10x_flash.c
  group User
    ./User/src/: main.c sys_init.c stm32f10x_it.c power.c usart.c command.c 3Gnet.c
  group DOC
    ./DOC/: readme.txt

# Keil uVision project user.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407ZGTx STMicroelectronics
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: user
  AfterMake: fromelf --bin  --output .\bin\bootloader.bin  .\user.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,__FPU_USED,
  c include: ..\code\sys\Include;..\code\bsp\inc;..\code\user;..\code\drv\inc;..\code\DSP_LIB\Include;..\code\drv\USB\STM32_USB_Device_Library\Class\msc\inc;..\code\drv\USB\STM32_USB_Device_Library\Core\inc;..\code\drv\USB\STM32_USB_HOST_Library\Class\MSC\inc;..\code\drv\USB\STM32_USB_HOST_Library\Core\inc;..\code\drv\USB\STM32_USB_OTG_Driver\inc;..\code\drv\USB\USB_APP;..\code\PICTURE;..\code\TEXT;..\code\FATFS\exfuns;..\code\FATFS\src
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group sys
    ../code/sys/: system_stm32f4xx.c startup_stm32f40_41xxx.s sys.c malloc.c
  group bsp
    ../code/bsp/src/: misc.c stm32f4xx_dbgmcu.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_iwdg.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c stm32f4xx_dma2d.c
  group user
    ../code/user/: main.c protocol.c
  group drv
    ../code/drv/src/: usart.c other.c stmflash.c iap.c
  group test
    ../code/test/: TestUsart.c TestBoot.c

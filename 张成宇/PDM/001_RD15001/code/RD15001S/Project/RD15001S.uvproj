# Keil uVision project RD15001S.uvproj, settings and files
target user (MCS-51)
  device: C8051F340 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(48000000)
  output: RD15001S +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\code
  group user
    ../code/: app_rfid.c hum_tem.c Init.c main.c protocol.c Test.c TestRfid.c usart.c STARTUP.A51

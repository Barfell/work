# Keil uVision project YL_LPC1788_APP.uvproj, settings and files
target FLASH (ARM-ADS)
  device: LPC1788 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: YL_LPC1788_Test +hex
  c flags: Optim=1
  c include: ..\app;..\CM3_lib;..\Drivers;..\Startup;.\Easy_web;.\Lcd_Drv;.\IIC_Test;.\USU_Host;.\Nand_Test;.\FATFS_R0.08;..\fs
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT6: RAM 0xa0000000 size 0x2000000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  scatter file: .\Flash\YL_LPC1788_Test.sct
  group Startup
    ../Startup/: startup_LPC177x_8x.s system_LPC177x_8x.c
  group CM3_lib
    ../CM3_lib/: core_cm3.c
  group Drivers
    ../Drivers/: debug_frmwrk.c lpc177x_8x_clkpwr.c lpc177x_8x_dac.c lpc177x_8x_emc.c lpc177x_8x_exti.c lpc177x_8x_gpdma.c lpc177x_8x_gpio.c sdram_k4s561632j.c lpc177x_8x_nvic.c lpc177x_8x_qei.c lpc177x_8x_timer.c lpc177x_8x_uart.c nandflash_k9f2g08u0x.c lpc177x_8x_pinsel.c
  group App
    ./: main.c download.c
  group fs
    ../fs/: flash2K.c yaffs_checkptrw.c yaffs_ecc.c yaffs_guts.c yaffs_nand.c yaffs_packedtags2.c yaffs_qsort.c yaffs_tagscompat.c yaffs_tagsvalidity.c yaffscfg2k.c yaffsfs.c
target RAM (ARM-ADS)
  device: LPC1788 NXP (founded by Philips)
  cpu: as above
  output: YL_LPC1788_Test +hex
  c flags: Optim=1
  c define: __RAM_MODE__
  c include: ..\app;..\CM3_lib;..\Drivers;..\Startup;.\Easy_web;.\Lcd_Drv;.\IIC_Test
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000

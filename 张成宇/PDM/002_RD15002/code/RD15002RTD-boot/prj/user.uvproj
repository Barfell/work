# Keil uVision project user.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F101C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x200027FF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: user
  AfterMake: fromelf --bin  --output .\bin\RD15002RTD_boot.bin  .\user.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c misc: --c99
  c include: ..\code\bsp\inc;..\code\sys\Include;..\code\user\Include;..\code\test;..\code\drv\inc;..\code\app\inc;..\code\app\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group bsp
    ../code/bsp/src/: misc.c stm32f10x_dbgmcu.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_spi.c stm32f10x_crc.c
  group sys
    ../code/sys/: core_cm3.c system_stm32f10x.c startup_stm32f10x_md.s kernal.c
  group user
    ../code/user/: main.c readme.txt
    ../code/drv/src/: Protocol.c
  group test
    ../code/test/: TestLed.c TestTimer.c TestUart.c TestSST25VF0.c
  group drv
    ../code/drv/src/: Led.c serial.c timer.c SST25VF064C.c spi.c Dtu.c
  group app
    ../code/app/src/: flash.c UartBoot.c DtuBoot.c

# Keil uVision project user.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407ZGTx STMicroelectronics
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: user
  AfterMake: fromelf --bin  --output .\bin\RD15003M_APP.bin  .\user.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,USE_USB_OTG_FS,__FPU_USED,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c misc: --C99
  c include: ..\code\sys\Include;..\code\bsp\inc;..\code\user;..\code\drv\inc;..\code\DSP_LIB\Include;..\code\drv\USB\STM32_USB_Device_Library\Class\msc\inc;..\code\drv\USB\STM32_USB_Device_Library\Core\inc;..\code\drv\USB\STM32_USB_HOST_Library\Class\MSC\inc;..\code\drv\USB\STM32_USB_HOST_Library\Core\inc;..\code\drv\USB\STM32_USB_OTG_Driver\inc;..\code\drv\USB\USB_APP;..\code\PICTURE;..\code\TEXT;..\code\FATFS\exfuns;..\code\FATFS\src
  memory RVCT4: ROM 0x8010000 size 0xf0000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group sys
    ../code/sys/: system_stm32f4xx.c startup_stm32f40_41xxx.s malloc.c kernal.c
  group bsp
    ../code/bsp/src/: misc.c stm32f4xx_adc.c stm32f4xx_dbgmcu.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_iwdg.c stm32f4xx_rcc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c stm32f4xx_dma2d.c stm32f4xx_can.c
  group DSP_LIB
    ../code/DSP_LIB/: arm_cortexM4lf_math.lib tool.lib
  group FATS
    ../code/FATFS/src/: diskio.c ff.c
    ../code/FATFS/exfuns/: exfuns.c fattester.c mycc936.c
  group PICTURE
    ../code/PICTURE/: bmp.c gif.c piclib.c tjpgd.c
  group TEXT
    ../code/TEXT/: fontupd.c text.c
  group USB_OTG
    ../code/drv/USB/STM32_USB_OTG_Driver/src/: usb_core.c usb_hcd.c usb_hcd_int.c
  group USB_HOST
    ../code/drv/USB/STM32_USB_HOST_Library/Class/MSC/src/: usbh_msc_bot.c usbh_msc_core.c usbh_msc_scsi.c
    ../code/drv/USB/STM32_USB_HOST_Library/Core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
  group USB_APP
    ../code/drv/USB/USB_APP/: usb_bsp.c usbh_usr.c
  group user
    ../code/user/: main.c app_usb.c readme.txt protocol.c
  group drv
    ../code/drv/src/: usart.c comm.c syn.c beep.c can.c led.c pwc.c SST25VF064C.c key.c
  group test
    ../code/test/: TestUsart.c TestComm.c TestUsb.c TestNandflah.c TestSyn.c TestBeep.c TestCan.c TestLed.c TestSST25VF0.c TestStim300.c TestPwc.c

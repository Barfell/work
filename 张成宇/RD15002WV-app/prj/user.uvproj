# Keil uVision project user.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: user
  AfterMake: fromelf --bin  --output .\bin\RD15002WV_APP.bin  .\user.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,USE_USB_OTG_FS,__FPU_USED,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c misc: --C99
  c include: ..\code\sys\Include;..\code\bsp\inc;..\code\user;..\code\drv\inc;..\code\DSP_LIB\Include;..\code\drv\USB\STM32_USB_Device_Library\Class\msc\inc;..\code\drv\USB\STM32_USB_Device_Library\Core\inc;..\code\drv\USB\STM32_USB_HOST_Library\Class\MSC\inc;..\code\drv\USB\STM32_USB_HOST_Library\Core\inc;..\code\drv\USB\STM32_USB_OTG_Driver\inc;..\code\drv\USB\USB_APP;..\code\PICTURE;..\code\TEXT;..\code\FATFS\exfuns;..\code\FATFS\src
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group sys
    ../code/sys/: system_stm32f4xx.c startup_stm32f40_41xxx.s malloc.c kernal.c
  group bsp
    ../code/bsp/src/: misc.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_rtc.c stm32f4xx_pwr.c stm32f4xx_crc.c
  group DSP_LIB
    ../code/DSP_LIB/: arm_cortexM4lf_math.lib
  group user
    ../code/user/: main.c readme.txt protocol.c
  group drv
    ../code/drv/src/: usart.c SST25VF064C.c rtc.c ltc2402.c spi.c FreqMeasurement.c bsp_init.c bsp_io_control.c
  group test
    ../code/test/: TestUsart.c TestSST25VF0.c TestRtc.c TestLtc2402.c TestFrequency.c

# Keil uVision project project.uvproj, settings and files
target SCT (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  AfterMake: D:\Program Files\mdk\ARM\ARMCC\bin\fromelf.exe --bin --output .\bin\123.bin .\project.axf
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx
  c include: ..\code\app\inc;..\code\app\src;..\code\bsp\inc;..\code\bsp\src;..\code\drv\inc;..\code\drv\src;..\code\sys;..\code\test;..\code\user;..\code\sys\inc;..\code\sys\src;..\code\GSM\src;..\code\GSM\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8020000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group app
    ../code/app/src/: FreqMeasurement.c Temperature.c 485.c
  group bsp
    ../code/bsp/src/: misc.c stm32f4xx_adc.c stm32f4xx_crc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group drv
    ../code/drv/src/: bsp_adc.c bsp_init.c bsp_io_control.c bsp_rtc.c bsp_sst25vf064.c bsp_usart.c bsp_flash.c stm32f4xx_it.c
  group sys
    ../code/sys/: startup_stm32f40xx.s system_stm32f4xx.c
  group user
    ../code/user/: Tools.c main.c includes.h
  group gsm
    ../code/GSM/src/: Dtu.c Protocol.c serial.c TestDtu.c flash.c kernal.c
